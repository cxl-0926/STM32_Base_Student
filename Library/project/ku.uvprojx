# Keil uVision project ku.uvprojx, settings and files
target ku_Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ku +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\lib\inc;..\user;..\user\API\ADC;..\user\API\GPIO;..\user\API\SPI;..\user\API\USART;..\user\API\Delay;..\user\API\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../core/: core_cm3.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group strup
    ../strup/: startup_stm32f10x_hd.s
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
  group API
    ../user/API/GPIO/: led.c
    ../user/API/Delay/: delay.c
    ../user/API/TIM/: tim.c
    ../user/API/USART/: usart1.c
